<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Clock_IN12B_stm32f030k6t6.ewp</path>
    </project>
    <batchBuild />
</workspace>
